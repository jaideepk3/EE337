
// -- DO NOT CHANGE ANYTHING UNTIL THE **** LINE--//
ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL ADD16
HERE: SJMP HERE
ORG 130H
// *****************
ADD16:
// ADD YOUR CODE HERE
MOV 70H, #0fFH
MOV 71H, #0fFH
MOV 72H, #0fFH
MOV 73H, #0fFH
MOV A, 71H
MOV B, 73H
ADD A, B
MOV 76H, A
MOV A, 70H
MOV B, 72H
ADDC A, B
MOV 75H, A
MOV A, #0H
ADDC A, #0H
MOV 74H, A

RET
END