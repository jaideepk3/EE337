ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL SEARCH

HERE: SJMP HERE
ORG 130H
	
SEARCH:
CLR C
MOV R0,30H
MOV R2,31H
MOV R3,32H
MOV A,R2
JZ L2
MOV B,#02H
DIV AB
MOV 34H,A
ADD A,R0
MOV R5,A
MOV R1,A
MOV A,@R1
CJNE A,32H,L0
MOV 33H,R1
RET

L0:
MOV A,34H
JZ L2
MOV A,#00 ;D>S
ADDC A,#00
JNZ L1
MOV 31H,34H
CALL SEARCH
RET

L1:
CLR C ;D<S
MOV 30H,R5
MOV A,34H
ADD A,B
MOV 31H,A
CALL SEARCH
RET

L2:
MOV 33H,#0EH
RET

END